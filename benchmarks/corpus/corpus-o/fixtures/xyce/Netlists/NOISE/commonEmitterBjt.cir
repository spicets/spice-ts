* gnetlist -g spice-sdb CommonEmitterI.sch
*********************************************************
* Spice file generated by gnetlist                      *
* spice-sdb version 4.28.2007 by SDB --                 *
* provides advanced spice netlisting capability.        *
* Documentation at http://www.brorson.com/gEDA/SPICE/   *
*********************************************************
*==============  Begin SPICE netlist of main design ============
.noise V(OUT) V1 oct 10 .01 1e3 1

* Verify that case does not matter in the device names or noise type names
* for the DNO and DNI operators.
.print noise {sqrt(abs(inoise))} {sqrt(abs(onoise))}
+ {sqrt(abs(DNO(r3)))} {sqrt(abs(DNO(r1)))}
+ {sqrt(abs(DNO(r5)))} {sqrt(abs(DNO(r4)))}
+ {sqrt(abs(DNO(Q1,rc)))} {sqrt(abs(DNO(q1,rb)))} {sqrt(abs(DNO(q1,re)))}
+ {sqrt(abs(DNO(q1,IC)))} {sqrt(abs(DNO(q1,IB)))}
+ {sqrt(abs(DNO(q1,FN)))} {sqrt(abs(DNO(Q1)))} {sqrt(abs(DNO(r2)))}
+ {sqrt(abs(DNI(r3)))} {sqrt(abs(DNI(r1)))}
+ {sqrt(abs(DNI(r5)))} {sqrt(abs(DNI(r4)))}
+ {sqrt(abs(DNI(Q1,RC)))} {sqrt(abs(DNI(q1,RB)))} {sqrt(abs(DNI(q1,RE)))}
+ {sqrt(abs(DNI(q1,ic)))} {sqrt(abs(DNI(q1,ib)))}
+ {sqrt(abs(DNI(q1,fn)))} {sqrt(abs(DNI(q1)))} {sqrt(abs(DNI(r2)))}

R5 0 OUT 1MEG
V1 1 0 sin 0 1 1meg AC 1
V2 Vcc 0 12
C2 Vc OUT 10u
R4 0 Ve 270
R3 Vc Vcc 1.5k
Q1 Vc Vb Ve 2N2222
.MODEL 2N2222 NPN (Is=14.34f Xti=3 Eg=1.11 Vaf=74.03 Bf=255.9 Ne=1.307 Ise=14.34f Ikf=.2847 Xtb=1.5 Br=6.092 Nc=2 Isc=0 Ikr=0 Rc=1 Cjc=7.306p Mjc=.3416 Vjc=.75 Fc=.5 Cje=22.01p Mje=.377 Vje=.75 Tr=46.91n Tf=411.1p Itf=.6 Vtf=1.7 Xtf=3 Rb=10)
R2 0 Vb 6.8k
R1 Vb Vcc 39k
C1 1 Vb 10u
.end
